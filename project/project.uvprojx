# Keil uVision project project.uvprojx, settings and files
target rt-thread-nano (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUGx,USE_STDPERIPH_DRIVER
  c include: ..\libraries\CMSIS\Include;..\libraries\Device\MegaHunt\mhscpu\Include;..\libraries\MHSCPU_Driver\inc;..\app;..\app\rtos;..\rt-thread\include;..\rt-thread\include\libc;..\rt-thread\components\device;..\rt-thread\components\finsh
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group app
    ../app/: main.c
  group app/rtos
    ../app/rtos/: board.c
  group libraries
    ../libraries/MHSCPU_Driver/src/: mhscpu_adc.c mhscpu_bpk.c mhscpu_cache.c mhscpu_crc.c mhscpu_dac.c mhscpu_dma.c mhscpu_exti.c mhscpu_gpio.c mhscpu_hspim.c mhscpu_hspis.c mhscpu_i2c.c mhscpu_it.c mhscpu_otp.c mhscpu_qspi.c mhscpu_rtc.c mhscpu_spi.c mhscpu_ssc.c mhscpu_sysctrl.c mhscpu_timer.c mhscpu_uart.c mhscpu_wdt.c misc.c
  group cmsis
    ../libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
    ../libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group rt-thread/src
    ../rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group rt-thread/libcpu
    ../rt-thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
software components: CMSIS:CORE 5.4.0
